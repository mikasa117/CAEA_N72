# Keil uVision project Project.uvprojx, settings and files
target Project (6240000::V6.24::ARMCLANG)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: Project +hex
  AfterMake: "..\..\..\..\components\tools\keil\post_process.bat" "@L" "#L" "$J"
  c flags: Optim=2 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=3
  c include: ..\..\..\..\components\btdm\include;..\..\..\..\components\drivers\cmsis;..\..\..\..\components\drivers\device\fr30xx;..\..\..\..\components\drivers\peripheral\Inc;..\..\..\..\components\modules\common\include;..\..\..\..\components\modules\FlashDB\flashdb\inc;..\..\..\..\components\modules\FlashDB\port\fal\inc;..\..\..\..\components\modules\FreeRTOS\include;..\..\..\..\components\modules\FreeRTOS\portable\ARMv8M\non_secure;..\..\..\..\components\modules\FreeRTOS\portable\ARMv8M\non_secure\portable\GCC\ARM_CM33_NTZ;..\..\..\..\components\modules\heap;..\..\..\common\btdm;..\..\..\common\flashdb;..\Inc;..\Src;..\Src\SWD;..\..\..\..\components\modules\crc;..\..\..\..\components\modules\lwip-STABLE-2_1_3_RELEASE\src\include;..\..\..\common\lwip_port;..\..\..\common\lwip_port\arch;..\..\..\..\components\modules\audio;..\..\..\..\components\modules\audio\algorithm;..\..\..\..\components\modules\audio\codec;..\..\..\..\components\modules\audio\resample;..\..\..\..\components\modules\rpmsg-lite\lib\include;..\..\..\..\components\modules\rpmsg-lite\lib\include\platform\fr30xx_m33;..\..\..\..\components\modules\dsp;..\..\..\common\btdm\profile\ble_hid;..\..\..\common\btdm\profile\ble_simple_gatt;..\..\..\common\btdm\profile\ble_ANCS_AMCS;..\Src\Bsw\Mcal_If\adc_if;..\Src\Bsw\Mcal_If\dio_if;..\Src\Bsw\SystemService\SysM;..\Src\Bsw\SystemService\EcuM;..\Src\Bsw\ComplexDrivers\Switch;..\Src\Bsw\ComplexDrivers\Battery;..\Src\Bsw\ComplexDrivers\Audio;..\Src\Bsw\STD_Lib;..\Src\Hmi;..\..\..\common\btdm\profile\ble_batt;..\Src\Net\CanDrv;..\Src\Net\Manual\Can_Rte;..\Src\Net\Manual\CanApp;..\Src\Net\Manual\CanCbk;..\Src\Net\Manual\CanDcm;..\Src\Net\Manual\CanDem;..\Src\Net\Manual\CANE2E;..\Src\Net\Manual\CanFbl;..\Src\Net\Manual\CanMain;..\Src\Net\Manual\CanSec;..\Src\Net\Manual\CanTrcv;..\Src\Net\Vector\GenyConfig;..\Src\Net\Vector\StaticCode\Can;..\Src\Net\Vector\StaticCode\Ccl;..\Src\Net\Vector\StaticCode\Common;..\Src\Net\Vector\StaticCode\Il;..\Src\Net\Vector\StaticCode\SipVersionCheck;..\Src\Net\Vector\StaticCode\Tp;..\Src\Net\Vector\StaticCode\VStdLib;..\Src\Bsw\ComplexDrivers\DiagServ\DID_Callback;..\Src\Bsw\ComplexDrivers\DiagServ\DTC_Callback;..\Src\Net\Manual\Security_Key
  library: MicroLIB
  memory RVCT4: ROM 0x8030000 size 0x1000
  memory RVCT5: ROM 0x8031000 size 0x9ee00
  memory RVCT9: RAM 0x20000000 size 0x3fe00
  memory RVCT10: RAM 0x20040000 size 0x40000
  scatter file: ..\..\..\..\components\tools\keil\xip_flash_add_psram.sct
  group CMSIS
    ../../../../components/drivers/cmsis/: core_cm33.h
  group app
    ../Src/: main.c app_at.c app_ble.c app_bt.c app_btdm.c app_task.c user_bt.c app_audio.c app_rpmsg.c mp3_sample.c msbc_sample.c sbc_sample.c app_hid_sdp.c hci_test.c
    ../Inc/: app_config.h
  group ble/profile
    ../../../common/btdm/profile/ble_simple_gatt/: simple_gatt_service.c
    ../../../common/btdm/profile/ble_hid/: hid_service.c
    ../../../common/btdm/profile/ble_ANCS_AMCS/: AMS_client.c ANCS_AMS_client.c
  group common/btdm
    ../../../common/btdm/: btdm_mem.c controller.c host.c SWD.c controller_code.s
    ../../../common/btdm/profile/ble_batt/: batt_service.c
  group common/flashdb
    ../../../common/flashdb/: fal_flash_port.c fdb_app.c
  group common/dsp
    ../../../common/dsp/: dsp_code_rom.s
  group driver/device
    ../../../../components/drivers/device/fr30xx/: fr30xx.h system_fr30xx.c system_fr30xx.h trim_fr30xx.c
    ../../../../components/drivers/device/fr30xx/armcc/: startup_fr30xx.s
  group driver/peripheral
    ../../../../components/drivers/peripheral/Src/: driver_cali.c driver_efuse.c driver_flash.c driver_frspim.c driver_gpio.c driver_pmu.c driver_pmu_iwdt.c driver_qspi.c driver_uart.c driver_trng.c driver_psd_dac.c driver_i2s.c driver_ipc.c driver_pdm.c driver_saradc.c driver_can.c driver_spi_master.c driver_wdt.c
  group module/btdm
    ../../../../components/btdm/: btdm_host.lib
  group module/common
    ../../../../components/modules/common/src/: co_log.c co_list.c co_util.c
  group module/flashdb
    ../../../../components/modules/FlashDB/port/fal/src/: fal.c fal_flash.c fal_partition.c
    ../../../../components/modules/FlashDB/flashdb/src/: fdb.c fdb_kvdb.c fdb_utils.c
  group module/freertos
    ../../../../components/modules/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c freertos_sleep.c cpu_context.s
    ../../../../components/modules/FreeRTOS/portable/ARMv8M/non_secure/: port.c
    ../../../../components/modules/FreeRTOS/portable/ARMv8M/non_secure/portable/GCC/ARM_CM33_NTZ/: portasm.c
    ../../../../components/modules/FreeRTOS/portable/MemMang/: heap_6.c
  group module/heap
    ../../../../components/modules/heap/: heap.c
  group module/crc
    ../../../../components/modules/crc/: crc32.c
  group moudle/lwip
    ../../../../components/modules/lwip-STABLE-2_1_3_RELEASE/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../components/modules/lwip-STABLE-2_1_3_RELEASE/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../components/modules/lwip-STABLE-2_1_3_RELEASE/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../components/modules/lwip-STABLE-2_1_3_RELEASE/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../components/modules/lwip-STABLE-2_1_3_RELEASE/src/netif/: ethernet.c
  group moudle/lwip_port
    ../../../common/lwip_port/: ethernetif.c sys_arch.c
  group module/audio
    ../../../../components/modules/audio/: audio_a2dp_sink.c audio_a2dp_source.c audio_decoder.c audio_encoder.c audio_hw.c audio_rpmsg.c audio_scene.c audio_sco.c local_playback.c loopback.c recorder.c audio_loop.c
    ../../../../components/modules/audio/resample/: resample.c
    ../../../../components/modules/audio/codec/: codec.c
    ../../../../components/modules/audio/algorithm/: algorithm.c
  group modules/rpmsg-lite
    ../../../../components/modules/rpmsg-lite/lib/rpmsg_lite/: rpmsg.c rpmsg_lite.c rpmsg_ns.c rpmsg_queue.c
    ../../../../components/modules/rpmsg-lite/lib/common/: llist.c
    ../../../../components/modules/rpmsg-lite/lib/virtio/: virtqueue.c
    ../../../../components/modules/rpmsg-lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
    ../../../../components/modules/rpmsg-lite/lib/rpmsg_lite/porting/platform/fr30xx_cm33/: rpmsg_platform.c
  group modules/dsp
    ../../../../components/modules/dsp/: dsp.c dsp_mem.c
  group Bsw/Mcal_If
    ../Src/Bsw/Mcal_If/adc_if/: adc_if.c
    ../Src/Bsw/Mcal_If/dio_if/: dio_if.c
  group Bsw/SystemService
    ../Src/Bsw/SystemService/: task.c
    ../Src/Bsw/SystemService/EcuM/: EcuM.c
    ../Src/Bsw/SystemService/SysM/: SysM.c SysM_Cfg.c
  group Bsw/ComplexDrivers
    ../Src/Bsw/ComplexDrivers/Switch/: Switch.c
    ../Src/Bsw/ComplexDrivers/Battery/: STD_BtrM.c
    ../Src/Bsw/STD_Lib/: STD_Lib.c
  group Bsw/Audio
    ../Src/Bsw/ComplexDrivers/Audio/: audio_codec.c codec_es8389.c driver_iic_soft.c
  group HMI
    ../Src/Hmi/: Hmi.c Rte_Hmi.c Hmi_Callback.c Hmi_Core.c Hmi_Protocol.c Hmi_Tasks.c
  group Net/CanDrv
    ../Src/Net/CanDrv/: CanDrv.c
  group Net/Manual/Can_Rte
    ../Src/Net/Manual/Can_Rte/: Rte_Can.c
  group Net/Manual/CanApp
    ../Src/Net/Manual/CanApp/: CanApp.c CanAppCfg.c
  group Net/Manual/CanCbk
    ../Src/Net/Manual/CanCbk/: Appl_Can_Callback.c Appl_Ccl_Callback.c Appl_Il_Callback.c Appl_Tp_Callback.c NmControl.c BusOff_Recovery.c
  group Net/Manual/CanDcm
    ../Src/Net/Manual/CanDcm/: Appl_CPID_Callback.c Appl_Desc_Callback.c Appl_DID_Callback.c
  group Net/Manual/CanDem
    ../Src/Net/Manual/CanDem/: CanDem.c CanDem_Callback.c CanDem_Cfg.c
  group Net/Manual/CANE2E
    ../Src/Net/Manual/CANE2E/: E2E.c
  group Net/Manual/Security_Key
    ../Src/Net/Manual/Security_Key/: security_key.c
  group Net/Manual/CanFbl
    ../Src/Net/Manual/CanFbl/: base.c
  group Net/Manual/CanMain
    ../Src/Net/Manual/CanMain/: Can_Main.c
  group Net/Manual/CanSec
    ../Src/Net/Manual/CanSec/: Random.c
  group Net/Manual/CanTrcv
    ../Src/Net/Manual/CanTrcv/: Can_Trcv.c
  group Net/Vector/GenyConfig
    ../Src/Net/Vector/GenyConfig/: appdesc.c appdescdev.c can_par.c ccl_par.c desc.c drv_par.c il_par.c nmcbdwrp_par.c tp_par.c v_par.c
  group Net/Vector/StaticCode/Can
    ../Src/Net/Vector/StaticCode/Can/: can_drv.c
  group Net/Vector/StaticCode/Ccl
    ../Src/Net/Vector/StaticCode/Ccl/: ccl.c
  group Net/Vector/StaticCode/Il
    ../Src/Net/Vector/StaticCode/Il/: il.c
  group Net/Vector/StaticCode/SipVersionCheck
    ../Src/Net/Vector/StaticCode/SipVersionCheck/: sip_vers.c
  group Net/Vector/StaticCode/Tp
    ../Src/Net/Vector/StaticCode/Tp/: tpmc.c
  group Net/Vector/StaticCode/VStdLib
    ../Src/Net/Vector/StaticCode/VStdLib/: vstdlib.c
  group Bsw/ComplexDrivers/DiagServ/DID_Callback
    ../Src/Bsw/ComplexDrivers/DiagServ/DID_Callback/: DID_Callback.c
  group Bsw/ComplexDrivers/DiagServ/DTC_Callback
    ../Src/Bsw/ComplexDrivers/DiagServ/DTC_Callback/: DTC_Callback.c
software components: Compiler:I/O:STDERR 1.2.0
